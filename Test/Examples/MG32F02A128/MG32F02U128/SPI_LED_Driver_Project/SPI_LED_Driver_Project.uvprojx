# Keil uVision project SPI_LED_Driver_Project.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: MG32F02U128 Megawin
  pack: Megawin.CM0_DFP.4.2.0
  cpu: IRAM(0x20000000,0x3800) IRAM2(0x20003800,0x800) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SPI_LED_Driver_Project
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\User\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3800
  memory RVCT10: RAM 0x20003800 size 0x800
  group Main
    ./User/Source/: main.c
  group RGB
    ./User/Source/: MG32x02z_RGB_API.c MG32x02z_RGB_MBIA045_API.c MG32x02z_RGB_TLC5948_API.c MG32x02z_RGBTable_API.c
software components: CMSIS:CORE 5.5.0, ChipInit_Wizard:CSC 1.0.4, ChipInit_Wizard:GPIO 1.0.0, Device:Startup 1.0.4, Driver:Driver-All 1.0.1
